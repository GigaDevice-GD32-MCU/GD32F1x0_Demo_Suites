# Keil uVision project GD32150C-START.uvproj, settings and files
target HID_keyboard (ARM-ADS)
  device: GD32F150C8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HID_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c misc: --c99
  c include: ..\inc;..\..\..\Utilities;..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_library\usbd\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_library\device\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_library\class\device\hid\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../src/: main.c gd32f1x0_it.c gd32f1x0_usbd_hw.c hid_keyboard_itf.c
  group CMSIS
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_Peripherals
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c
  group GD32F150C_START
    ../../../Utilities/: gd32f150c_start.c
  group USBD_Drivers
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Doc
    ../: readme.txt
